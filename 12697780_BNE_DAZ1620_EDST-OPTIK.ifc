Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b730758d-76e8-43a6-a34a-4b06bd5af93f, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:40:59+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12697780_BNE_DAZ1620_EDST-OPTIK:28Z1620S_BNE_12697780_DAZ1620_EDST-OPTIK, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 599 mm; Height: 450 mm; Depth: 275 mm
Classification: E1090320 Uniformat (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Design_Glass, Aluminum, z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir
Pset_BuildingElementProxyCommon - Reference: 28Z1620S_BNE_12697780_DAZ1620_EDST-OPTIK; sets with these values: 2
